<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Eiro_Charger_Station.ewp</path>
    </project>
    <batchBuild />
</workspace>
